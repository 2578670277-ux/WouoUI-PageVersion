# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\sys;..\HAREWARE\LED;..\LetterShell;..\LetterShell\Log;..\HAREWARE\KEY;..\HAREWARE\USART23;..\HAREWARE\PACK;..\HAREWARE\OLED_SPI;..\WouoUI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HAREWARE
    ../HAREWARE/LED/: led.c
    ../HAREWARE/OLED_SPI/: oled_port.c
    ../HAREWARE/USART23/: USART23.c
  group LetterShell
    ../LetterShell/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c shell_port.c
    ../LetterShell/Log/: log.c
  group WouoUI
    ../WouoUI/: WouoUI.c WouoUI_anim.c WouoUI_font.c WouoUI_graph.c WouoUI_msg.c WouoUI_page.c WouoUI_user.c WouoUI_win.c
